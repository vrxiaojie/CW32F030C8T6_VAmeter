<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc; *.md</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp; *.cc; *.cxx</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>Project</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\Listings\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <bEvRecOn>1</bEvRecOn>
        <bSchkAxf>0</bSchkAxf>
        <bTchkAxf>0</bTchkAxf>
        <nTsel>6</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>STLink\ST-LINKIII-KEIL_SWO.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ST-LINKIII-KEIL_SWO</Key>
          <Name>-U066BFF525256836687104011 -O206 -SF4000 -C0 -A0 -I0 -HNlocalhost -HP7184 -P1 -TO131090 -TC10000000 -TT10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO15 -FD20000000 -FC1000 -FN1 -FF0FlashCW32F030.FLM -FS00 -FL010000 -FP0($$Device:CW32F030C8$Flash\FlashCW32F030.FLM) -WA0 -WE0 -WVCE4 -WS2710 -WM0 -WP2 -WK0</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMRTXEVENTFLAGS</Key>
          <Name>-L70 -Z18 -C0 -M0 -T1</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=2968,469,3344,705,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>CMSIS_AGDI</Key>
          <Name>-X"Any" -UAny -O206 -S9 -C0 -P00000000 -N00("ARM CoreSight SW-DP") -D00(0BC11477) -L00(0) -TO65554 -TC10000000 -TT10000000 -TP20 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO15 -FD20000000 -FC1000 -FN1 -FF0FlashCW32F030.FLM -FS00 -FL010000 -FP0($$Device:CW32F030C8$Flash\FlashCW32F030.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 -FD20000000 -FC1000 -FN1 -FF0FlashCW32F030 -FS00 -FL010000 -FP0($$Device:CW32F030C8$Flash\FlashCW32F030.FLM))</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>SystemCoreClock,0x10</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>u32rtnVal,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>sysclksource,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>hsiprs,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>1</WinNumber>
          <ItemText>pllmul,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>1</WinNumber>
          <ItemText>pllrefclk,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>1</WinNumber>
          <ItemText>a,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>1</WinNumber>
          <ItemText>SystemCoreClock,0x0A</ItemText>
        </Ww>
      </WatchWindow1>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <bLintAuto>0</bLintAuto>
      <bAutoGenD>0</bAutoGenD>
      <LntExFlags>0</LntExFlags>
      <pMisraName></pMisraName>
      <pszMrule></pszMrule>
      <pSingCmds></pSingCmds>
      <pMultCmds></pMultCmds>
      <pMisraNamep></pMisraNamep>
      <pszMrulep></pszMrulep>
      <pSingCmdsp></pSingCmdsp>
      <pMultCmdsp></pMultCmdsp>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>APP</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\main.h</PathWithFileName>
      <FilenameWithoutPath>main.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\GUI.c</PathWithFileName>
      <FilenameWithoutPath>GUI.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\GUI.h</PathWithFileName>
      <FilenameWithoutPath>GUI.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\Lcd_Driver.c</PathWithFileName>
      <FilenameWithoutPath>Lcd_Driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\Lcd_Driver.h</PathWithFileName>
      <FilenameWithoutPath>Lcd_Driver.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>7</FileNumber>
<<<<<<< HEAD
=======
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\LCD_Config.h</PathWithFileName>
      <FilenameWithoutPath>LCD_Config.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>8</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\esp8266_cmd.c</PathWithFileName>
      <FilenameWithoutPath>esp8266_cmd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>8</FileNumber>
=======
      <FileNumber>9</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\esp8266_cmd.h</PathWithFileName>
      <FilenameWithoutPath>esp8266_cmd.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>9</FileNumber>
=======
      <FileNumber>10</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\menu.c</PathWithFileName>
      <FilenameWithoutPath>menu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>10</FileNumber>
=======
      <FileNumber>11</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\menu.h</PathWithFileName>
      <FilenameWithoutPath>menu.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>11</FileNumber>
=======
      <FileNumber>12</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\Font.h</PathWithFileName>
      <FilenameWithoutPath>Font.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>12</FileNumber>
=======
      <FileNumber>13</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\key.c</PathWithFileName>
      <FilenameWithoutPath>key.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>13</FileNumber>
=======
      <FileNumber>14</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\key.h</PathWithFileName>
      <FilenameWithoutPath>key.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>14</FileNumber>
=======
      <FileNumber>15</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\tim.c</PathWithFileName>
      <FilenameWithoutPath>tim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>15</FileNumber>
=======
      <FileNumber>16</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\tim.h</PathWithFileName>
      <FilenameWithoutPath>tim.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>16</FileNumber>
=======
      <FileNumber>17</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\Picture.c</PathWithFileName>
      <FilenameWithoutPath>Picture.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>17</FileNumber>
=======
      <FileNumber>18</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\Picture.h</PathWithFileName>
      <FilenameWithoutPath>Picture.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>18</FileNumber>
=======
      <FileNumber>19</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\mqtt.c</PathWithFileName>
      <FilenameWithoutPath>mqtt.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>19</FileNumber>
=======
      <FileNumber>20</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\mqtt.h</PathWithFileName>
      <FilenameWithoutPath>mqtt.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>20</FileNumber>
=======
      <FileNumber>21</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\sys.c</PathWithFileName>
      <FilenameWithoutPath>sys.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>21</FileNumber>
=======
      <FileNumber>22</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\sys.h</PathWithFileName>
      <FilenameWithoutPath>sys.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>22</FileNumber>
=======
      <FileNumber>23</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\adc.c</PathWithFileName>
      <FilenameWithoutPath>adc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>23</FileNumber>
=======
      <FileNumber>24</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\adc.h</PathWithFileName>
      <FilenameWithoutPath>adc.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>24</FileNumber>
=======
      <FileNumber>25</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\va_meter.c</PathWithFileName>
      <FilenameWithoutPath>va_meter.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>25</FileNumber>
=======
      <FileNumber>26</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\va_meter.h</PathWithFileName>
      <FilenameWithoutPath>va_meter.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>26</FileNumber>
=======
      <FileNumber>27</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\sht40.c</PathWithFileName>
      <FilenameWithoutPath>sht40.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>27</FileNumber>
=======
      <FileNumber>28</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\sht40.h</PathWithFileName>
      <FilenameWithoutPath>sht40.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>28</FileNumber>
=======
      <FileNumber>29</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\str.c</PathWithFileName>
      <FilenameWithoutPath>str.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
<<<<<<< HEAD
      <FileNumber>29</FileNumber>
=======
      <FileNumber>30</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\str.h</PathWithFileName>
      <FilenameWithoutPath>str.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
<<<<<<< HEAD
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\gpio.c</PathWithFileName>
      <FilenameWithoutPath>gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>31</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\APP\gpio.h</PathWithFileName>
      <FilenameWithoutPath>gpio.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
=======
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
  </Group>

  <Group>
    <GroupName>STARTUP</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>32</FileNumber>
=======
      <FileNumber>31</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>..\..\Board\startup_cw32f030.s</PathWithFileName>
=======
      <PathWithFileName>..\..\APP\startup_cw32f030.s</PathWithFileName>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FilenameWithoutPath>startup_cw32f030.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>BSP</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>33</FileNumber>
=======
      <FileNumber>32</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\BSP\uart\bsp_uart.c</PathWithFileName>
      <FilenameWithoutPath>bsp_uart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Board</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>34</FileNumber>
=======
      <FileNumber>33</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\system_cw32f030.c</PathWithFileName>
      <FilenameWithoutPath>system_cw32f030.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>35</FileNumber>
=======
      <FileNumber>34</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Board\board.c</PathWithFileName>
      <FilenameWithoutPath>board.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Driver</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>36</FileNumber>
=======
      <FileNumber>35</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_adc.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_adc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>37</FileNumber>
=======
      <FileNumber>36</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_atim.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_atim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>38</FileNumber>
=======
      <FileNumber>37</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_awt.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_awt.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>39</FileNumber>
=======
      <FileNumber>38</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_btim.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_btim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>40</FileNumber>
=======
      <FileNumber>39</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_crc.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_crc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>41</FileNumber>
=======
      <FileNumber>40</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_debug.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_debug.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>42</FileNumber>
=======
      <FileNumber>41</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_digitalsign.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_digitalsign.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>43</FileNumber>
=======
      <FileNumber>42</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_dma.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_dma.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>44</FileNumber>
=======
      <FileNumber>43</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_flash.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_flash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>45</FileNumber>
=======
      <FileNumber>44</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_gpio.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>46</FileNumber>
=======
      <FileNumber>45</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_gtim.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_gtim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>47</FileNumber>
=======
      <FileNumber>46</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_iwdt.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_iwdt.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>48</FileNumber>
=======
      <FileNumber>47</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_lvd.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_lvd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>49</FileNumber>
=======
      <FileNumber>48</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_pwr.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_pwr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>50</FileNumber>
=======
      <FileNumber>49</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_ram.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_ram.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>51</FileNumber>
=======
      <FileNumber>50</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_rcc.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_rcc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>52</FileNumber>
=======
      <FileNumber>51</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_rtc.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_rtc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>53</FileNumber>
=======
      <FileNumber>52</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_spi.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_spi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>54</FileNumber>
=======
      <FileNumber>53</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_systick.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_systick.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>55</FileNumber>
=======
      <FileNumber>54</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_uart.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_uart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>56</FileNumber>
=======
      <FileNumber>55</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_vc.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_vc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>57</FileNumber>
=======
      <FileNumber>56</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\Libraries\src\cw32f030_wwdt.c</PathWithFileName>
      <FilenameWithoutPath>cw32f030_wwdt.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>MODULE</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
  </Group>

  <Group>
    <GroupName>DOC</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>58</FileNumber>
=======
      <FileNumber>57</FileNumber>
>>>>>>> 0dfd7a7e8c0db99ec07f30fe2edd2e84eaf20952
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\README.md</PathWithFileName>
      <FilenameWithoutPath>README.md</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>::CMSIS</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>1</RteFlg>
  </Group>

</ProjectOpt>
